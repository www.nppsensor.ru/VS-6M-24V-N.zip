# KOMPAS-3D part (éæ-6î-24é-ì.m3d)

Model tree:
1. Объединить компоненты:1

Referenced files in D:\Работа\Мещеряков\Сигнализатор ВС\Черновики\: ВС-6М-24В-Н (.064).a3d